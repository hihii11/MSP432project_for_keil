# Keil uVision project Exin_AB_encoder.uvprojx, settings and files
target Exin_AB_encoder (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Exin_AB_encoder
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\exinlibs;..\ti;C:\Users\93793\AppData\Local\Arm\Packs\ARM\CMSIS\5.2.0\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group exinlibs
    ./exinlibs/: exin_library_map_guide.c exinADC.c exinADC0832.c exinadjust.c exineeprom.c exinencoder.c exingpio.c exinHC_SR04.c exinIIC.c exinisr.c exinkey.c exinmotor.c exinMPU6050.c exinpwm.c exinsteer.c exinsystem.c exinTimerA.c exinTimerAINT.c exinuart.c LMT70RD.c oled.c Oscill_OLED.c
    ../exinlibs/: config.c
  group exinlibs_link
    ./exinlibs/: bmp.h config.h dat.h exinADC.h exinADC0832.h exinadjust.h exineeprom.h exinencoder.h exingpio.h exinHC_SR04.h exinIIC.h exinisr.h exinkey.h exinmotor.h exinMPU6050.h exinpwm.h exinsteer.h exinsystem.h exinTimerA.h exinTimerAINT.h exinuart.h headfile.h LMT70RD.h oled.h oledfont.h Oscill_OLED.h
  group start
    ../start/: startup_msp432p401x_keil.s system_msp432p401x.c
  group user
    ./: main.c
